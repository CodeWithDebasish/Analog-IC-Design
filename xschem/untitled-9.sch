v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {op_nmos.sym} 860 50 0 0 {name=x1}
C {res.sym} -10 -140 1 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
