** sch_path: xschem/untitled-5.sch
**.subckt untitled-5
V1 net1 GND 3
R1 net2 net1 1k m=1
C1 GND net2 1p m=1
**.ends
.GLOBAL GND
.end
